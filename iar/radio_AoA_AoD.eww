<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\radio_AoA_AoD.ewp</path>
    </project>
    <batchBuild />
</workspace>
