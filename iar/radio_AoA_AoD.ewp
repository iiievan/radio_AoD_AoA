# IAR project radio_AoA_AoD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52811_xxAA NordicSemi nRF52811_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG_NFCT_PINS_AS_GPIOS; NRF52811_XXAA
  ICCARM.CCIncludePath2: ..\CMSIS\; ..\CMSIS\Include\; ..\CMSIS\Device\; ..\app
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: radio_AoA_AoD.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: nrf5281x_xxaa.icf
  ILINK.IlinkExtraOptions: --config_def cpu_id_52811=1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: nrf5281x_xxaa.icf
  group app
    ../app/: main.cpp n_RADIO_regs.h radio.cpp radio.h utils.c
  group CMSIS
    ../CMSIS/: iar_startup_nrf52811.s system_nrf52.c
